# Keil uVision project N32Test.uvprojx, settings and files
target N32Test (6230000::V6.23::.\ArmCompilerforEmbedded6.23)
  device: N32H474VE Nationstech
  pack: Nationstech.N32H47x_DFP.1.1.0
  cpu: IRAM1(0x20000000,0x30000) IROM1(0x08000000,0x80000) CPUTYPE(Cortex-M4) FPU2 CLOCK(12000000) ELITTLE
  output: N32Test +hex
  AfterMake: fromelf --bin --output=.\bin\N32Test.bin .\Objects\N32Test.axf
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32H474, USE_STDPERIPH_DRIVER
  c include: ..\USER\inc;..\Driver\CMSIS\core;..\Driver\CMSIS\device;..\Driver\n32h47x_48x_std_periph_driver\inc;..\gmp_src_mgr\gmp_inc;..\gmp_src_mgr\gmp_inc\csp\nation32_h47x;..\xplt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../Driver/CMSIS/device/startup/: startup_n32h47x_48x.s
  group CMSIS
    ../Driver/CMSIS/device/: system_n32h47x_48x.c
  group USER
    ../USER/src/: main.c n32h47x_48x_it.c n32h47x_48x_cfg.c ctl_main.c user_main.c
    ../USER/inc/: ctl_main.h main.h user_main.h
  group GMP
    ../gmp_src_mgr/gmp_src/: crc16.c ctl_adv_back_stepping.c ctl_adv_flc.c ctl_adv_flpid.c ctl_adv_ilc.c ctl_adv_imc.c ctl_adv_lms.c ctl_adv_lut_pair.c ctl_adv_mrac.c ctl_adv_rc.c ctl_adv_sinc_interpolator.c ctl_adv_smc.c ctl_adv_surf_search.c ctl_cia402_callback_fn.c ctl_cia402_state_machine.c ctl_component_interface.c ctl_continuous_pi.c ctl_continuous_pid.c ctl_continuous_pid_aw.c ctl_discrete_biquad_filter.c ctl_discrete_df.c ctl_discrete_filter.c ctl_discrete_lead_lag.c ctl_discrete_pid.c ctl_discrete_pole_zero.c ctl_discrete_pr.c ctl_discrete_sg.c ctl_discrete_sogi.c ctl_discrete_track_pid.c ctl_disrete_fir.c ctl_divider.c ctl_dp_basic.c ctl_dp_gfl_core.c ctl_dp_gfl_pq.c ctl_dp_gfm_droop.c ctl_dp_hcm.c ctl_dp_mppt_inc.c ctl_dp_mppt_po.c ctl_dp_neg_ctrl.c ctl_dp_pll_ddsrf.c ctl_dp_pll_dsogi.c ctl_dp_pll_srf.c ctl_dp_sinv_core.c ctl_dp_spfc.c ctl_dp_spll_sogi.c ctl_dp_spll_sogi_dc.c ctl_hysteresis_controller.c ctl_if_pwm_h.c ctl_if_pwm_npc.c ctl_if_pwm_spwm.c ctl_internal_ladrc1.c ctl_internal_ladrc2.c ctl_itoc_protection.c ctl_mc_acim_consultant.c ctl_mc_acim_fo.c ctl_mc_acim_pos_calc.c ctl_mc_acim_smo.c ctl_mc_ato_pll.c ctl_mc_basic_mech_ctrl.c ctl_mc_bldc_hall.c ctl_mc_bldc_zcd_obs.c ctl_mc_dtc_svm_core.c ctl_mc_encoder.c ctl_mc_encoder_switcher.c ctl_mc_foc_core.c ctl_mc_imfoc_core.c ctl_mc_inverter_consultant.c ctl_mc_ipm_fw.c ctl_mc_ladrc_pos_ctrl.c ctl_mc_ladrc_spd_ctrl.c ctl_mc_lut_fw.c ctl_mc_mech_consultant.c ctl_mc_mit_mech_ctrl.c ctl_mc_mtr_protection.c ctl_mc_mtr_vf_generator.c ctl_mc_nameplate_consultant.c ctl_mc_pmsm_consultant.c ctl_mc_pmsm_dbptc.c ctl_mc_pmsm_esmo.c ctl_mc_pmsm_fo.c ctl_mc_pmsm_hfi.c ctl_mc_pu_consultant.c ctl_mc_s_curve_traj.c ctl_mc_smc_mech_ctrl.c ctl_mc_sogi_traj.c ctl_mc_spm_fw.c ctl_mc_trapezoudal_traj.c ctl_nano.c ctl_protection.c ctl_sag_swell.c ctl_saturation.c ctl_slope_limiter.c ctl_sogi.c ctl_track_pid.c dcdc_boost_hw.c dcdc_buck_hw.c dcdc_clllc_hw.c dcdc_core.c dcdc_fsbb_hw.c gmp_at_device.c gmp_datalink.c gmp_dev_util.c gmp_mem_presp.c gmp_mm_block_memory.c gmp_pil_core.c gmp_process_mgr.c gmp_std_error_code.c gmp_std_port.c gmp_tunable.c n32_csp_adapter.c
  group xPlt
    ../xplt/: ctrl_settings.h xplt.config.h xplt.ctl_interface.h xplt.peripheral.c xplt.peripheral.h
  group FWLB
    ../Driver/n32h47x_48x_std_periph_driver/src//: n32h47x_48x_flash.c n32h47x_48x_rcc.c misc.c n32h47x_48x_dma.c n32h47x_48x_gpio.c n32h47x_48x_usart.c n32h47x_48x_fdcan.c n32h47x_48x_i2c.c n32h47x_48x_dac.c n32h47x_48x_rtc.c n32h47x_48x_adc.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_fmac.c n32h47x_48x_shrtim.c n32h47x_48x_pwr.c n32h47x_48x_tim.c
