# Keil uVision project stm32g030f6p6_demo.uvprojx, settings and files
target stm32g030f6p6_demo (6230000::V6.23::.\ArmCompilerforEmbedded6.23)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g030f6p6_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\User;..\gmp_src_mgr\gmp_inc;..\gmp_src_mgr\gmp_inc\csp\stm32
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group GMP/TP/IQmath
    ../../../../third_party/iqmath/src/: _atoIQN.c _IQNasin_acos.c _IQNatan2.c _IQNdiv.c _IQNdiv.h _IQNexp.c _IQNfrac.c _IQNlog.c _IQNmpy.c _IQNmpy.h _IQNmpyIQX.c _IQNrepeat.c _IQNrmpy.c _IQNrsmpy.c _IQNsin_cos.c _IQNsqrt.c _IQNtables.c _IQNtables.h _IQNtoa.c _IQNtoF.c _IQNversion.c
  group User
    ../User/: ctl_main.c peripheral.c user_main.c
  group GMP/src
    ../gmp_src_mgr/gmp_src/: ctl_cia402_callback_fn.c ctl_cia402_state_machine.c ctl_component_advance.c ctl_component_basic.c ctl_component_continuous.c ctl_component_discrete.c ctl_component_interface.c ctl_component_protection.c ctl_dp_basic.c ctl_dp_mppt.c ctl_dp_single_phase.c ctl_dp_three_phase.c ctl_dp_topology_inv.c ctl_dp_topology_sinv.c ctl_mc_acm_sensored_ctrl.c ctl_mc_basic.c ctl_mc_consultant.c ctl_mc_current_loop.c ctl_mc_motion.c ctl_mc_observer.c ctl_mc_pmsm_ctrl.c ctl_mc_pmsm_ctrl_hfi.c ctl_mc_pmsm_ctrl_mtpa.c ctl_mc_pmsm_ctrl_smo.c ctl_mc_pmsm_offline_est.c ctl_nano.c dsa_trigger.c gmp_at_device.c gmp_dev_util.c gmp_mm_block_memory.c gmp_process_mgr.c gmp_std_error_code.c gmp_std_port.c hdc1080.c ht16k33.c PCA9555.c stm32_chip_common.c stm32_peripheral_driver.c
software components: CMSIS:CORE 5.6.0
