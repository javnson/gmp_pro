# Keil uVision project stm32g431.uvprojx, settings and files
target stm32g431 (5060750::V5.06 update 6 (build 750)::.\ARMCCV5)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32g431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../../../../../gmp_pro;../../../../../../csp/stm32;../../../src;../xplt;../sdpe_mgr;../../../sdpe_general
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group GMP/source
    ../gmp_src_mgr/gmp_src/: ctl_cia402_callback_fn.c ctl_cia402_state_machine.c ctl_component_advance.c ctl_component_basic.c ctl_component_continuous.c ctl_component_discrete.c ctl_component_interface.c ctl_component_protection.c ctl_dp_basic.c ctl_dp_mppt.c ctl_dp_single_phase.c ctl_dp_three_phase.c ctl_dp_topology_inv.c ctl_dp_topology_sinv.c ctl_mc_acm_sensored_ctrl.c ctl_mc_basic.c ctl_mc_consultant.c ctl_mc_current_loop.c ctl_mc_motion.c ctl_mc_observer.c ctl_mc_pmsm_ctrl.c ctl_mc_pmsm_ctrl_hfi.c ctl_mc_pmsm_ctrl_mtpa.c ctl_mc_pmsm_ctrl_smo.c ctl_mc_pmsm_offline_est.c ctl_nano.c gmp_at_device.c gmp_dev_util.c gmp_ds_list.c gmp_mm_block_memory.c gmp_process_mgr.c gmp_std_error_code.c gmp_std_port.c stm32_chip_common.c dsa_trigger.c
  group xplt
    ../sdpe_mgr/: sdpe_pgs_inv_gfl_stm32g431_settings.h
    ../../../implement/stm32g431/: xplt.config.h xplt.ctl_interface.h xplt.peripheral.c xplt.peripheral.h
  group user
    ../../../implement/common/: ctl_main.c ctl_main.h user_main.c user_main.h
software components: CMSIS:CORE 4.3.0
