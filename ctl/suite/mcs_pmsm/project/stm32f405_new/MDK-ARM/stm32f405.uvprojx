# Keil uVision project stm32f405.uvprojx, settings and files
target stm32f405 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f405 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../../../../../gmp_pro;../../../../../../csp/stm32;../../../implement/stm32f405_new;../../../implement/common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group GMP_SRC
    ../../../implement/stm32f405_new/: xplt.peripheral.c ctrl_settings.h xplt.config.h xplt.ctl_interface.h xplt.peripheral.h
  group GMP_COMMON
    ../../../implement/common/: ctl_main.c ctl_main.h user_main.c user_main.h
  group GMP_CORESRC
    ../gmp_src/: ctl_component_advance.c ctl_component_basic.c ctl_component_continuous.c ctl_component_discrete.c ctl_component_interface.c ctl_component_protection.c ctl_mc_acm_sensored_ctrl.c ctl_mc_basic.c ctl_mc_consultant.c ctl_mc_current_loop.c ctl_mc_motion.c ctl_mc_observer.c ctl_mc_pmsm_ctrl.c ctl_mc_pmsm_ctrl_hfi.c ctl_mc_pmsm_ctrl_mtpa.c ctl_mc_pmsm_ctrl_smo.c ctl_mc_pmsm_offline_est.c ctl_nano.c gmp_dev_util.c gmp_ds_list.c gmp_mm_block_memory.c gmp_std_error_code.c gmp_std_port.c stm32_chip_common.c
software components: CMSIS:CORE 4.3.0
