# Keil uVision project stm32g474_hrtim.uvprojx, settings and files
target stm32g474_hrtim (5060750::V5.06 update 6 (build 750)::.\ARMCCV5)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32g474_hrtim +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../gmp_src_mgr/gmp_inc;../gmp_src_mgr/gmp_inc/csp/stm32;../../../../../..;../xplt;../sdpe_mgr;../../../src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group GMP/src
    ../gmp_src_mgr/gmp_src/: crc16.c ctl_adv_back_stepping.c ctl_adv_flc.c ctl_adv_flpid.c ctl_adv_ilc.c ctl_adv_imc.c ctl_adv_lms.c ctl_adv_lut_pair.c ctl_adv_mrac.c ctl_adv_rc.c ctl_adv_sinc_interpolator.c ctl_adv_smc.c ctl_adv_surf_search.c ctl_cia402_callback_fn.c ctl_cia402_state_machine.c ctl_component_interface.c ctl_continuous_pi.c ctl_continuous_pid_aw.c ctl_continuous_pid.c ctl_discrete_biquad_filter.c ctl_discrete_df.c ctl_discrete_filter.c ctl_discrete_lead_lag.c ctl_discrete_pid.c ctl_discrete_pole_zero.c ctl_discrete_pr.c ctl_discrete_sg.c ctl_discrete_sogi.c ctl_discrete_track_pid.c ctl_disrete_fir.c ctl_divider.c ctl_dp_basic.c ctl_dq_ladrc1.c ctl_dq_pi.c ctl_hysteresis_controller.c ctl_if_pwm_h.c ctl_if_pwm_npc.c ctl_if_pwm_spwm.c ctl_internal_ladrc1.c ctl_internal_ladrc2.c ctl_itoc_protection.c ctl_mc_acim_consultant.c ctl_mc_acim_fo.c ctl_mc_acim_pos_calc.c ctl_mc_acim_smo.c ctl_mc_ato_pll.c ctl_mc_basic_mech_ctrl.c ctl_mc_bldc_hall.c ctl_mc_bldc_zcd_obs.c ctl_mc_dtc_svm_core.c ctl_mc_encoder_switcher.c ctl_mc_encoder.c ctl_mc_foc_core.c ctl_mc_imfoc_core.c ctl_mc_inverter_consultant.c ctl_mc_ipm_fw.c ctl_mc_ladrc_pos_ctrl.c ctl_mc_ladrc_spd_ctrl.c ctl_mc_lut_fw.c ctl_mc_mech_consultant.c ctl_mc_mit_mech_ctrl.c ctl_mc_mtr_protection.c ctl_mc_mtr_vf_generator.c ctl_mc_nameplate_consultant.c ctl_mc_pmsm_consultant.c ctl_mc_pmsm_dbptc.c ctl_mc_pmsm_esmo.c ctl_mc_pmsm_fo.c ctl_mc_pmsm_hfi.c ctl_mc_pu_consultant.c ctl_mc_s_curve_traj.c ctl_mc_smc_mech_ctrl.c ctl_mc_sogi_traj.c ctl_mc_spm_fw.c ctl_mc_trapezoudal_traj.c ctl_nano.c ctl_protection.c ctl_sag_swell.c ctl_saturation.c ctl_slope_limiter.c ctl_sogi.c ctl_track_pid.c dcdc_boost_hw.c dcdc_buck_hw.c dcdc_clllc_hw.c dcdc_core.c dcdc_fsbb_hw.c dsa_dl_scope.c dsa_scope.c dsa_trigger.c gmp_at_device.c gmp_datalink.c gmp_mem_presp.c gmp_mm_block_memory.c gmp_pil_core.c gmp_scope.c gmp_tunable.c stm32_chip_common.c stm32_peripheral_driver.c ctl_adv_fdrc.c ctl_mc_acm_sensored_ctrl.c ctl_mc_pmsm_ctrl.c error_code.c function_scheduler.c gmp_dev_print.c gmp_dl_facility.c gmp_runtime.c ring_buffer.c
  group GMP/xplt
    ../sdpe_mgr/: ctrl_settings.h
    ../xplt/: xplt.config.h xplt.ctl_interface.h xplt.peripheral.c xplt.peripheral.h
  group GMP/user
    ../../../src/: ctl_main.c ctl_main.h user_main.c user_main.h
software components: CMSIS:CORE 4.3.0
