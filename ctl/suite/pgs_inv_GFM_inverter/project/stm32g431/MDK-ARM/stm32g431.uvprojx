# Keil uVision project stm32g431.uvprojx, settings and files
target stm32g431 (5060750::V5.06 update 6 (build 750)::.\ARMCCV5)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32g431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../../../../pgs_inv_GFL_inverter/project/stm32g431/Drivers/STM32G4xx_HAL_Driver/Inc;../../../../pgs_inv_GFL_inverter/project/stm32g431/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../../../../pgs_inv_GFL_inverter/project/stm32g431/Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../pgs_inv_GFL_inverter/project/stm32g431/Drivers/CMSIS/Include;../gmp_src_mgr/gmp_inc;../gmp_src_mgr/gmp_inc/csp/stm32;../../../../../..;../../../src;../xplt;../sdpe_mgr;../../../sdpe_general
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../pgs_inv_GFL_inverter/project/stm32g431/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group GMP/source
    ../gmp_src_mgr/gmp_src/: crc16.c ctl_adv_back_stepping.c ctl_adv_fdrc.c ctl_adv_flc.c ctl_adv_flpid.c ctl_adv_ilc.c ctl_adv_imc.c ctl_adv_lms.c ctl_adv_lut_pair.c ctl_adv_mrac.c ctl_adv_rc.c ctl_adv_sinc_interpolator.c ctl_adv_smc.c ctl_adv_surf_search.c ctl_cia402_callback_fn.c ctl_cia402_state_machine.c ctl_component_interface.c ctl_continuous_pi.c ctl_continuous_pid_aw.c ctl_continuous_pid.c ctl_discrete_biquad_filter.c ctl_discrete_df.c ctl_discrete_filter.c ctl_discrete_lead_lag.c ctl_discrete_pid.c ctl_discrete_pole_zero.c ctl_discrete_pr_tuner.c ctl_discrete_pr.c ctl_discrete_sg.c ctl_discrete_sogi.c ctl_discrete_track_pid.c ctl_disrete_fir.c ctl_divider.c ctl_dp_basic.c ctl_dp_gfl_core.c ctl_dp_gfm_droop_ctrl.c ctl_dp_gfm_transition.c ctl_dp_gfm_virtual_impedance.c ctl_dp_gfm_vsm_ctrl.c ctl_dp_hcm.c ctl_dp_mppt_inc.c ctl_dp_mppt_po.c ctl_dp_neg_ctrl.c ctl_dp_pll_ddsrf.c ctl_dp_pll_dsogi.c ctl_dp_pll_srf.c ctl_dp_sinv_core.c ctl_dp_spfc.c ctl_dp_spll_sogi_dc.c ctl_dp_spll_sogi.c ctl_dp_voltage_ctrl.c ctl_dp_zero_ctrl.c ctl_hysteresis_controller.c ctl_if_pwm_h.c ctl_if_pwm_npc.c ctl_if_pwm_spwm.c ctl_internal_ladrc1.c ctl_internal_ladrc2.c ctl_itoc_protection.c ctl_mc_encoder_switcher.c ctl_mc_encoder.c ctl_nano.c ctl_protection.c ctl_sag_swell.c ctl_saturation.c ctl_slope_limiter.c ctl_sogi.c ctl_track_pid.c dcdc_boost_hw.c dcdc_buck_hw.c dcdc_clllc_hw.c dcdc_core.c dcdc_fsbb_hw.c dsa_dl_scope.c dsa_scope.c dsa_trigger.c gmp_at_device.c gmp_datalink.c gmp_dev_print.c gmp_mem_presp.c gmp_mm_block_memory.c gmp_pil_core.c function_scheduler.c gmp_scope.c error_code.c gmp_runtime.c gmp_tunable.c ring_buffer.c stm32_chip_common.c stm32_peripheral_driver.c
  group xplt
    ../sdpe_mgr/: sdpe_pgs_inv_gfm_stm32g431_settings.h
    ../xplt/: xplt.config.h xplt.ctl_interface.h xplt.peripheral.c xplt.peripheral.h
  group user
    ../../../src/: ctl_main.c ctl_main.h user_main.c user_main.h
software components: CMSIS:CORE 4.3.0
