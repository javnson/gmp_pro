# Keil uVision project stm32_dl_dbger.uvprojx, settings and files
target stm32_dl_dbger (6230000::V6.23::.\ArmCompilerforEmbedded6.23)
  device: STM32C092RCTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200077FF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32_dl_dbger +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C092xx
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include;../user;../xplt;../gmp_src_mgr/gmp_inc;../gmp_src_mgr/gmp_inc/csp/stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x7800
  group Application/MDK-ARM
    ./: startup_stm32c092xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_fdcan.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_spi.c stm32c0xx_hal_spi_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group Application/GMP User
    ../user/: user_main.c ctl_main.c
  group Application/GMP Platform
    ../xplt/: xplt.peripheral.c
  group GMP/Generated Sources
    ../gmp_src_mgr/gmp_src/: crc16.c ctl_divider.c ctl_hysteresis_controller.c ctl_saturation.c ctl_slope_limiter.c dsa_dl_scope.c dsa_scope.c dsa_trigger.c error_code.c function_scheduler.c gmp_datalink.c gmp_dev_print.c gmp_dl_facility.c gmp_mem_presp.c gmp_mm_block_memory.c gmp_pil_core.c gmp_runtime.c gmp_scope.c gmp_tunable.c stm32_chip_common.c stm32_peripheral_driver.c
software components: CMSIS:CORE 5.6.0
